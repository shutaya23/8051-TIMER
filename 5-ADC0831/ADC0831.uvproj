# Keil uVision project ADC0831.uvproj, settings and files
target arget 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: ADC0831 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ADC0831.c
